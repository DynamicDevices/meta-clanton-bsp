
RPROVIDES_${PN} += " linux-firmware-iwlwifi-licence"

